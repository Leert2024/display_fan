# Keil uVision project 2025_RoboCup_Medical.uvprojx, settings and files
target 2025_RoboCup_Medical (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 2025_RoboCup_Medical +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Core/BUPT_RobotTeam_Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: common.c serial.c main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BUPT_RobotTeamLibraries/SimpleLib
    ../Core/BUPT_RobotTeam_Libraries/SimpleLib/: simplelib.c
    ../Core/BUPT_RobotTeam_Libraries/SimpleLib/can/: can_func.c can_utils.c
    ../Core/BUPT_RobotTeam_Libraries/SimpleLib/utils/: hash.c kalman.c utils.c vec.c
    ../Core/BUPT_RobotTeam_Libraries/SimpleLib/cmd/: cmd.c cmd_func.c
    ../Core/BUPT_RobotTeam_Libraries/SimpleLib/core/: soft_timer.c
  group BUPT_RobotTeamLibraries/MotorLib
    ../Core/BUPT_RobotTeam_Libraries/MotorLib/: dji_boardv2_can.c dji_boardv2_uart.c crc_calc.c xm430.c M2006.c
  group BUPT_RobotTeamLibraries/hardware
    ../Core/BUPT_RobotTeam_Libraries/hardware/fan/: fan.c pattern.c
    ../Core/BUPT_RobotTeam_Libraries/hardware/ws2812/: ws2812.c
software components: CMSIS:CORE 4.3.0
